# Repository can-ayaz/STM32F765-Gelistirme-Kart-Yapimi

File README.md:

**STM32F765-Gelistirme-Kart-Yapimi**

Merhaba Arkadaşlar bu yazımda ST Microelectronics firmasının tasarlamış olduğu  STM32F765VIT6 Mikrodenetleyicisine uygun bir geliştirme kartı tasarlayacağız ve programlayacağız. Microchip, Atmel, NXP, STM vs. derken artık ileri seviye ARM Mcu hayatımıza girerek kullanımı artıyor. Bende gerek günümüzde diğer mikrodenetleyicilerden uygun fiyatlı oluşu ve yapacağım projeme en uygun ve çevre birimlerinin çok olduğu için STM32F765VIT6 Arm® Cortex®-M7 32-bit RISC core Mikrodenetleyicisini seçtim, kullanışlı bir deney kartı ile Arm Mikrodenetleyici kartının projelerimizde kullanımına başlayabiliriz. 

**Daha fazlası içi ziyaret edebilirsiniz:**
**https://canayazblog.wordpress.com/**

## EAGLE design stm32f765-M7/eagle/STM32F765-M7/stm32f765-M7.brd

Parts:
5V_IN: M01PTH_LONGPAD; 1X01_LONGPAD
C1, C2, C9: 2uF2; 1206
C3, C4, C5, C6, C7, C17: 100nF; 1206
C8, C12, C13, C14, C15, C16: 10nF; 1206
C10, C11: 18pF; 1206
CRYSTAL: 8MHZ; CSM-7X-DU
JP1: PINHD-1X07_2.54; 1X07
JP2: PINHD-1X09_2.54; 1X09
JP3: PINHD-1X23_2.54; 1X23
JP5: PINHD-1X20_2.54; 1X20
JP6: PINHD-1X16_2.54; 1X16
JP7: M02; 1X02_LONGPADS
LED1: BLUE; 1206
PINS_3V3, PINS_5V: PINHD-1X05_2.54; 1X05
PINS_GND: PINHD-1X05_2.54; 1X05
POWER_LED: GREEN; 1206
R5, R6: 10K; 1206
R9, R10: 330; 1206
R11: 15K; 1206
R12: 22K; 1206
R13, R14: 22; 1206
REG113NA-3.3: V_REG_LDOSMD; SOT23-5
SD1, SD2: 400mA/40V/470mV; SOT23-3
SWDIO: M01PTH_LONGPAD; 1X01_LONGPAD
U$1: STM32F765VIT6; LQFP100
U$7: USB-MINIB-5PIN; USB-MINIB

Connections:
2_PE3: JP1.7, U$1.2 (PE3)
3V3: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C12.2, C13.2, PINS_3V3.1, PINS_3V3.2, PINS_3V3.3, PINS_3V3.4, PINS_3V3.5, R6.2, R9.1, R10.1, REG113NA-3.3.5 (OUT), U$1.6 (VBAT), U$1.11 (VDD), U$1.20 (VREF+), U$1.21 (VDDA), U$1.27 (VDD), U$1.50 (VDD1), U$1.75 (VDD), U$1.100 (VDD)
3_PE4: JP1.6, U$1.3 (PE4)
4_PE5: JP1.5, U$1.4 (PE5)
5V: 5V_IN.1, SD2.1 (A)
5_PE6: JP1.4, U$1.5 (PE6)
7_PC13: JP1.3, U$1.7 (PC13-ANTI_TAMP)
8_PC14: JP1.2, U$1.8 (PC14-OSC32_IN)
9_PC15: JP1.1, U$1.9 (PC15-OSC32_OUT)
15_PC0: JP2.8, U$1.15 (PC0)
16_PC1: JP2.7, U$1.16 (PC1)
17_PC2: JP2.6, U$1.17 (PC2)
18_PC3: JP2.5, U$1.18 (PC3)
22_PA0: JP2.4, U$1.22 (PAO-WKUP)
23_PA1: JP2.3, U$1.23 (PA1)
24_PA2: JP2.2, U$1.24 (PA2)
25_PA3: JP2.1, U$1.25 (PA3)
28_PA4: JP5.1, U$1.28 (PA4)
29_PA5: JP5.2, U$1.29 (PA5)
30_PA6: JP5.3, U$1.30 (PA6)
31_PA7: JP5.4, U$1.31 (PA7)
32_PC4: JP5.5, U$1.32 (PC4)
33_PC5: JP5.6, U$1.33 (PC5)
34_PB0: JP5.7, U$1.34 (PB0)
35_PB1: JP5.8, U$1.35 (PB1)
36_PB2: JP5.9, U$1.36 (PB2)
37_PE7: JP5.10, U$1.37 (PE7)
38_PE8: JP5.11, U$1.38 (PE8)
39_PE9: JP5.12, U$1.39 (PE9)
40_PE10: JP5.13, U$1.40 (PE10)
41_PE11: JP5.14, U$1.41 (PE11)
42_PE12: JP5.15, U$1.42 (PE12)
43_PE13: JP5.16, U$1.43 (PE13)
44_PE14: JP5.17, U$1.44 (PE14)
45_PE15: JP5.18, U$1.45 (PE15)
51_PB12: JP6.16, U$1.51 (PB12)
52_PB13: JP6.15, U$1.52 (PB13)
53_PB14: JP6.14, U$1.53 (PB14)
54_PB15: JP6.13, U$1.54 (PB15)
55_PD8: JP6.12, U$1.55 (PD8)
56_PD9: JP6.11, U$1.56 (PD9)
57_PD10: JP6.10, U$1.57 (PD10)
58_PD11: JP6.9, U$1.58 (PD11)
61_PD14: JP6.6, U$1.61 (PD14)
62_PD15: JP6.5, U$1.62 (PD15)
63_PC6: JP6.4, U$1.63 (PC6)
64_PC7: JP6.3, U$1.64 (PC7)
65_PC8: JP6.2, U$1.65 (PC8)
66_PC9: JP6.1, U$1.66 (PC9)
68_PA9: JP7.2, U$1.68 (PA9)
69_PA10: JP7.1, U$1.69 (PA10)
77_PA15: JP3.22, U$1.77 (PA15)
78_PC10: JP3.21, U$1.78 (PC10)
79_PC11: JP3.20, U$1.79 (PC11)
80_PC12: JP3.19, U$1.80 (PC12)
81_PD0: JP3.18, U$1.81 (PD0)
82_PD1: JP3.17, U$1.82 (PD1)
83_PD2: JP3.16, U$1.83 (PD2)
84_PD3: JP3.15, U$1.84 (PD3)
85_PD4: JP3.14, U$1.85 (PD4)
86_PD5: JP3.13, U$1.86 (PD5)
87_PD6: JP3.12, U$1.87 (PD6)
88_PD7: JP3.11, U$1.88 (PD7)
89_PB3: JP3.10, U$1.89 (PB3)
90_PB4: JP3.9, U$1.90 (PB4)
91_PB5: JP3.8, U$1.91 (PB5)
92_PB6: JP3.7, U$1.92 (PB6)
93_PB7: JP3.6, U$1.93 (PB7)
97_PE0: JP3.2, U$1.97 (PE0)
98_PE1: JP3.1, U$1.98 (PE1)
BOOT0: JP3.5, R5.1, U$1.94 (BOOT0)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, PINS_GND.1, PINS_GND.2, PINS_GND.3, PINS_GND.4, PINS_GND.5, POWER_LED.2 (C), R5.2, R12.1, REG113NA-3.3.2 (GND), U$1.10 (VSS), U$1.19 (VSSA), U$1.26 (VSS), U$1.49 (VSS1), U$1.74 (VSS), U$1.99 (VSS), U$7.GND
I2C1_SCL: JP3.4, U$1.95 (PB8)
I2C1_SDA: JP3.3, U$1.96 (PB9)
I2C2_SCL: JP5.19, U$1.46 (PB10)
I2C2_SDA: JP5.20, U$1.47 (PB11)
I2C4_SCL: JP6.8, U$1.59 (PD12)
I2C4_SDA: JP6.7, U$1.60 (PD13)
LED1: LED1.2 (C), U$1.1 (PE2)
unnamed: POWER_LED.1 (A), R9.2
unnamed: LED1.1 (A), R10.2
unnamed: C15.2, C16.2, REG113NA-3.3.1 (IN), REG113NA-3.3.3 (EN), SD1.3 (C), SD2.3 (C)
unnamed: R14.1, U$7.D-
unnamed: R13.1, U$7.D+
NR: C14.2, REG113NA-3.3.4 (BP)
OSC_IN: C10.1, CRYSTAL.2, U$1.12 (PH0-OSC_IN)
OSC_OUT: C11.1, CRYSTAL.1, U$1.13 (PH1-OSC_OUT)
PA8: R11.1, R12.2, U$1.67 (PA8)
RESET: C17.2, JP2.9, R6.1, U$1.14 (NRST)
SWDCLK: JP3.23, U$1.76 (PA14)
SWDIO: SWDIO.1, U$1.72 (PA13)
USBDM: R14.2, U$1.70 (PA11)
USBDP: R13.2, U$1.71 (PA12)
VCAP1: C1.2, U$1.48 (VCAP1)
VCAP2: C2.2, U$1.73 (VCAP2)
VUSB: PINS_5V.1, PINS_5V.2, PINS_5V.3, PINS_5V.4, PINS_5V.5, R11.2, SD1.1 (A), U$7.VBUS

Notes on the sheet:
Power
USB
SWD
Pinout
MCU

Board: 2 copper layers, 91.0 x 70.5 mm, 44 parts (0 on the bottom side), 96 nets.

Notices in the files:
parts and their libraries:
01_SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
